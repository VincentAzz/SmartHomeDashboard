# Keil uVision project stm32SmartHome.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32SmartHome +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\HARDWARE\BEEP;.\HARDWARE\BH1750;.\HARDWARE\DHT11;.\HARDWARE\KEY;.\HARDWARE\LED;.\HARDWARE\OLED;.\NET\cJSON;.\NET\device;.\NET\MQTT;.\NET\onenet;.\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\EXTI;.\SYSTEM\sys;.\SYSTEM\TIMER;.\SYSTEM\usart;.\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ./HARDWARE/BEEP/: beep.c
    ./HARDWARE/BH1750/: bh1750.c
    ./HARDWARE/DHT11/: dht11.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LED/: led.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/EXTI/: exti.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/TIMER/: timer.c
    ./SYSTEM/usart/: usart.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWlib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group NET
    ./NET/cJSON/: cJSON.c
    ./NET/device/: esp8266.c
    ./NET/MQTT/: MqttKit.c
    ./NET/onenet/: onenet.c
